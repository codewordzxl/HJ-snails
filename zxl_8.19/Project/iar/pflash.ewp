# IAR project pflash.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 NXP MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MKV58F1M0VLQ24; TWR_KV58F220M; TOWER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\User\board; ..\..\CMSIS\Include; ..\..\Devices\drivers; ..\..\Devices\components\lists; ..\..\Devices\components\serial_manager; ..\..\Devices\components\uart; ..\..\Devices\drivers; ..\..\User\device; ..\..\User; ..\..\Devices\iar; ..\..\Devices\utilities; ..\..\Devices\utilities\debug_console; ..\..\Devices\utilities\str; ..\..\Devices
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: pflash.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group APP
    ../../User/: include.h IRQ_Handler.c main.c
  group Board
    ../../User/: Pid.c Pid.h Starting_line.c Starting_line.h System.c System.h System_Init.c System_Init.h
  group Source/CAMERA
    ../../User/: LQ_MT9V034.c LQ_MT9V034.h
  group Source/MKV58
    ../../User/device/: MKV58_ADC.c MKV58_ADC.h MKV58_DMA.c MKV58_DMA.h MKV58_FTM.c MKV58_FTM.h MKV58_GPIO.c MKV58_GPIO.h MKV58_GPIO_Cfg.h MKV58_IIC.c MKV58_IIC.h MKV58_PIT.c MKV58_PIT.h
  group Source/OLED
    ../../User/: LQ_12864.c LQ_12864.h
  group Source/UART
    ../../User/: LQ_UART.c LQ_UART.h
  group System/board
    ../../User/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group System/component/lists
    ../../Devices/components/lists/: generic_list.c generic_list.h
  group System/component/serial_manager
    ../../Devices/components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group System/component/uart
    ../../Devices/components/uart/: uart.h uart_adapter.c
  group System/device
    ../../Devices/: fsl_device_registers.h MKV58F24.h MKV58F24_features.h system_MKV58F24.c system_MKV58F24.h
  group System/drivers
    ../../Devices/drivers/: fsl_adc16.c fsl_adc16.h fsl_aoi.c fsl_aoi.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_hsadc.c fsl_hsadc.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_pwm.c fsl_pwm.h fsl_rcm.c fsl_rcm.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_trng.c fsl_trng.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group System/startup
    ../../Devices/iar/: startup_MKV58F24.s
  group System/utilities
    ../../Devices/utilities/: fsl_assert.c
    ../../Devices/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../Devices/utilities/str/: fsl_str.c fsl_str.h
