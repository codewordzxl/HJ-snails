# Keil uVision project pflash.uvprojx, settings and files
target pflash debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKV58F1M0xxx24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x2F000000,0x00010000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: pflash.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MKV58F1M0VLQ24, TWR_KV58F220M, TOWER
  c misc: --library_interface=armcc 
--diag_suppress=1296,186
  c include: ..\..\CMSIS\Include;..\..\Devices\components\lists;..\..\Devices\components\serial_manager;..\..\Devices\components\uart;..\..\Devices;..\..\Devices\drivers;..\..\Devices\utilities;..\..\Devices\utilities\str;..\..\Devices\utilities\debug_console;..\..\User;..\..\User\board;..\..\User\device
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x2f000000 size 0x10000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: --remove 
--legacyalign
  group source
    ../../User/: IRQ_Handler.c main.c include.h delay.c LQ_12864.c LQ_UART.c system_init.c system.c ZXL_ADC.c pid.c Round.c Element.c
    ../../User/device/: MKV58_GPIO.c MKV58_ADC.c MKV58_FTM.c MKV58_PIT.c
  group board
    ../../User/board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h readme.txt
  group drivers
    ../../Devices/: fsl_device_registers.h MKV58F24.h MKV58F24_features.h system_MKV58F24.c system_MKV58F24.h
  group device
    ../../Devices/drivers/: fsl_adc16.c fsl_adc16.h fsl_aoi.c fsl_aoi.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_hsadc.c fsl_hsadc.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_pwm.c fsl_pwm.h fsl_rcm.c fsl_rcm.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_trng.c fsl_trng.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group utilities
    ../../Devices/utilities/: fsl_assert.c
    ../../Devices/utilities/str/: fsl_str.c fsl_str.h
    ../../Devices/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group component/uart
    ../../Devices/components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../Devices/components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../Devices/components/lists/: generic_list.c generic_list.h
  group startup
    ../../Devices/arm/: startup_MKV58F24.s
  group CMSIS
    ../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h mpu_armv7.h mpu_armv8.h
target pflash release (ARM-ADS)
  device: MKV58F1M0xxx24 NXP
  pack: Keil.Kinetis_KVxx_DFP.1.6.0
  cpu: as above
  output: pflash.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_MKV58F1M0VLQ24, TWR_KV58F220M, TOWER
  c misc: --library_interface=armcc 
--diag_suppress=1296,186
  c include: ..;../../../..;../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/MKV58F24/drivers;../../../../../../devices/MKV58F24/drivers;../../../../../../devices/MKV58F24/drivers;../../../../../../devices/MKV58F24/drivers;../../../../../../devices/MKV58F24;../../../../../../devices/MKV58F24/utilities/str;../../../../../../devices/MKV58F24/utilities/debug_console;../../../../../../components/uart;../../../../../../components/serial_manager;../../../../../../components/serial_manager;../../../../../../devices/MKV58F24/drivers;../../../../../../components/lists;../../../../../../devices/MKV58F24/drivers;../../../../../../devices/MKV58F24/drivers
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x2f000000 size 0x10000
  scatter file: MKV58F1M0xxx24_flash.scf
  link misc: --remove 
--legacyalign
