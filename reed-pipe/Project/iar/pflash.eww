<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\IAR__project\Example\Test\iar\kv58.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>pflash</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>pflash</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>release</name>
            <member>
                <project>pflash</project>
                <configuration>release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>debug</name>
            <member>
                <project>pflash</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
